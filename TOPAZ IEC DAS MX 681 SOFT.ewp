# IAR project TOPAZ IEC DAS MX 681 SOFT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986BE9x Milandr MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS; STARTUP; SPL; SPL\inc; SPL\inc\USB_Library; APP\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TOPAZ IEC DAS MX 681 SOFT.hex
  ILINK.IlinkOutputFile: TOPAZ IEC DAS MX 681 SOFT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/src/: GPIO.c main.c
  group SPL
    SPL/src/: MDR32F9Qx_port.c
  group STARTUP
    STARTUP/: startup_MDR32F9Qx.s
