<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TOPAZ IEC DAS MX 681 SOFT.ewp</path>
    </project>
    <batchBuild />
</workspace>
